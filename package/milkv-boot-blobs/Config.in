## package/milkv-boot-blobs/Config.in
```kconfig
config BR2_PACKAGE_HOST_MILKV_BOOT_BLOBS
	bool "host-milkv-boot-blobs"
	default n
	help
	  BLOBs used to build milkv firmware objects
```
